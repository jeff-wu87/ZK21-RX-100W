# Keil uVision project wy20w.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: wy20w +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Libraries\inc;..\Usr;..\Usr\inc;..\Qi\Inc;..\QI_prototol;..\uart
  group startup
    ../Usr/: startup_cw32l010.s
    ../Libraries/src/: system_cw32l010.c
  group control
    ../Usr/src/: interrupts_cw32l010.c main.c app_control.c app_led.c app_protect.c
  group driver
    ../Libraries/src/: cw32l010_adc.c cw32l010_atim.c cw32l010_btim.c cw32l010_gpio.c cw32l010_sysctrl.c cw32l010_gtim.c cw32l010_uart.c cw32l010_flash.c cw32l010_iwdt.c cw32l010_vc.c
  group bsp
    ../Usr/src/: bsp_adc.c bsp_vc.c bsp_uart.c bsp_io.c bsp_flash.c
  group qi
    ../QI_prototol/: qi_tx_hw.c qi_tx_protocol.c
  group uart
    ../uart/: ring_buffer.c uart_handler.c uart_protocol.c
software components: CMSIS:CORE 4.3.0
